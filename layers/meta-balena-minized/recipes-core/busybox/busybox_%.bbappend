# Don't know if it is safe to do this
PTEST_BINDIR = "0"
