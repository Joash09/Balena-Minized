IMAGE_FSTYPES_minized-zynq7 = "tar.gz"

BALENA_BOOT_PARTITION_FILES_minized-zynq7 = ""
