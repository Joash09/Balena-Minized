SUPERVISOR_REPOSITORY_minized-zynq7 = "balena/armv7hf-supervisor"
