IMAGE_FSTYPES_minized-zynq7 = "tar.gz"

# Add files from deploy directory
INTERNAL_BOOT_PARTITION_FILES_minized-zynq7 = ""

# Find out bootloader config of eMMC Minized
INTERNAL_DEVICE_BOOTLOADER_CONFIG_minized-zynq7 = ""
INTERNAL_DEVICE_BOOTLOADER_CONFIG_PATH_minized-zynq7 = ""
