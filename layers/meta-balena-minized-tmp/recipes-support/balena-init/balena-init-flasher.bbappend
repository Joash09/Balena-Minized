# Identiify internal storage. QSPI for Minized
INTERNAL_DEVICE_KERNEL_minized-zynq7 = "" 

# Find out what the bootloader configuration file is
INTERNAL_DEVICE_BOOTLOADER_CONFIG_minized-zynq7 = ""

# Relative path to resin-boot partition
INTERNAL_DEVICE_BOOTLOADER_CONFIG_PATH_minized-zynq7 = ""
